# Keil uVision project PWM.uvprojx, settings and files
target PWM (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\PWM;..\FWLIB\inc;.\HARDWARE\ENCONDER;..\HARDWARE\HWT101;..\HARDWARE\VISION;..\HARDWARE\SERVO;..\HARDWARE\SPORT;..\HARDWARE\LIFTING;..\HARDWARE\pid
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/HWT101/: HWT101.c HWT101.h
    ../HARDWARE/SERVO/: SERVO.c SERVO.h
    ../HARDWARE/VISION/: vision.c vision.h
    ../HARDWARE/SPORT/: sport.c sport.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c
software components: CMSIS:CORE 5.6.0
